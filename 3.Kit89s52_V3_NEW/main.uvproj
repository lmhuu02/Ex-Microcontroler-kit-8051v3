# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ./DELAY/: delay.c
    ./DS1820/: ds18b20.c
    ./LCD1602/: lcd1602.c
    ./MTP/: mtp4x4.c
    ./UART/: uart.c
    ./KEY/: key.c
    ./ds1307/: ds1307.c
    ./EPP_24C08/: 24c08.c
    ./PCF8591/: PCF8591.C
    ./TIMER/: timer.c
