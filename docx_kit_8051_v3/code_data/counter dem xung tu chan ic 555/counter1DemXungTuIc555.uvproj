# Keil uVision project counter1DemXungTuIc555.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: counter1DemXungTuIc555 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: counter1DemXungTuIc555.c
