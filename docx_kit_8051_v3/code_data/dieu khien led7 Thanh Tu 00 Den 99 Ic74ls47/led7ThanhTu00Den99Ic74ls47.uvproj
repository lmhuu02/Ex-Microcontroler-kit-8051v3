# Keil uVision project led7ThanhTu00Den99Ic74ls47.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: led7ThanhTu00Den99Ic74ls47 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led7ThanhTu00Den99Ic74ls47.c
