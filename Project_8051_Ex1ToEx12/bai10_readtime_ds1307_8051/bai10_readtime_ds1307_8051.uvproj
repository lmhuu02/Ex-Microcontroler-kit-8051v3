# Keil uVision project bai10_readtime_ds1307_8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: bai10_readtime_ds1307_8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: bai10_readtime_ds1307_8051.c
