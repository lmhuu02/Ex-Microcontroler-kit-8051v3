# Keil uVision project i2c_epprom1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: i2c_epprom1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: i2c_epprom1.c lcd.c
