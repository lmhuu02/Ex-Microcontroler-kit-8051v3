# Keil uVision project Nhung8051DieuKhienLedDon.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Nhung8051DieuKhienLedDon +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Nhung8051DieuKhienLedDon.c
