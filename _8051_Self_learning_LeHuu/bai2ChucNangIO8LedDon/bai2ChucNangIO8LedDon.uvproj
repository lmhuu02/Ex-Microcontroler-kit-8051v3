# Keil uVision project bai2ChucNangIO8LedDon.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: bai2ChucNangIO8LedDon +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: bai2ChucNangIO8LedDon.c
